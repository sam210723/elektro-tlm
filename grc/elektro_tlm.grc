options:
  parameters:
    author: sam210723
    description: https://github.com/sam210723/elektro-tlm
    generate_options: qt_gui
    id: elektro_tlm
    output_language: python
    title: ELEKTRO-L2/L3 TLM Demodulator
  states: {}

blocks:
- name: file_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '1800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: file_rate/4
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '5000.0'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: 4e3
    rate: '10e-3'
    reference: '500e-3'
    type: complex
  states: {}
- name: analog_agc_xx_0_0_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: 4e3
    rate: '10e-3'
    reference: '500e-3'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2'
    max_iter: '4000'
    scale: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '224'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: file_rate
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '52001'
    psize: '1472'
    type: complex
    vlen: '28'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    nchan: '2'
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '0.625e-3'
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '3e-3'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: '1'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/(2*1), 1000)'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    axislabels: 'False'
    grid: 'True'
    gui_hint: 1,1
    legend: 'False'
    size: '256'
    type: complex
    update_time: '0.01'
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-65'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-15'
    ymin: '-65'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-65'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    color1: '2'
    gui_hint: 3,0,1,2
    ncols: '1792'
    nrows: '100'
    samp_rate: samp_rate
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    legend: 'False'
    size: '1200'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '0.3'
    ymin: '-0.3'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '256'
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: synced
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: synced
  states: {}

connections:
- [analog_agc_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc_xx_0_0_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', blocks_multiply_xx_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_1, '0', virtual_sink_1, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_agc_xx_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', blocks_moving_average_xx_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_moving_average_xx_0, '0']
- [virtual_source_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_1, '0', blocks_complex_to_real_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
